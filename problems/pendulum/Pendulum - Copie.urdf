Commit message: public defense

File: problems/pendulum/Pendulum - Copie.urdf (robot description, URDF)
Before this commit: robot SimplePendulum, 2 links, 1 joints
Links:
- added link obstacle; visual box size=0.2 0.2 0.2
- link base_link: geometry visual box size=0.2 0.2 0.2
